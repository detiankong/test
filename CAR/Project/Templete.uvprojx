# Keil uVision project Templete.uvprojx, settings and files
target LED (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Templete +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Core;..\FWlib\inc;..\Project;..\SYSTEM\delay;..\SYSTEM\sys;..\Hardware\led;..\Hardware\timer;..\Hardware\MPU6050;..\Hardware\MPU6050\eMPL;..\Hardware\bsp;..\Control;..\Control\PrepareData;..\Control\MotorOut;..\SYSTEM\usart;..\Hardware\usart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../Hardware/MPU6050/: mpu6050.c mpuiic.c
    ../Hardware/led/: led.c
    ../Hardware/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Hardware/bsp/: bsp.c
    ../Hardware/timer/: timer.c
    ../Hardware/usart/: usart_.c
  group CONTROL
    ../Control/: control.c
  group MOTOR_OUT
    ../Control/MotorOut/: motor_out.c
  group PREPARE_DATA
    ../Control/PrepareData/: prepare_data.c
